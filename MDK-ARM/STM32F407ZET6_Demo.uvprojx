# Keil uVision project STM32F407ZET6_Demo.uvprojx, settings and files
target STM32F407ZET6_Demo (ARM-ADS)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F407ZET6_Demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Ethernet/W5300;../Ethernet/APP;../Sensor;./screen
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c fsmc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Ethernet
    ../Ethernet/W5300/: socket.c socket.h w5300.c w5300.h w5300_conf.c w5300_conf.h wizchip_conf.c wizchip_conf.h eth_video.h
  group APP
    ../Ethernet/APP/: bsp_flash.c bsp_flash.h dhcp.c dhcp.h dns.c dns.h http_server.c http_server.h httputil.c httputil.h mqtt_client.c mqtt_client.h MqttKit.c MqttKit.h tcp_client.c tcp_client.h tcp_server.c tcp_server.h udp.c udp.h webpge.h cJSON.c
  group Sensor
    ../Sensor/: dht11.c dht11.h relay.c relay.h yl_69.c yl_69.h serial_studio.c serial_studio.h g5516.c
  group screen
    ./screen/: 24cxx.c GUI.c key.c lcd.c myiic.c show_LCD.c SPI.c sys.c touch.c
software components: CMSIS:CORE 3.40.0
